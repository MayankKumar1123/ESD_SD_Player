# Keil uVision project SD_File.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SD_File
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fd00000 size 0x2000
  group Source Files
    ./: SD_File.c Getline.c
  group Configuration Files
    ./: LPC2300.s File_Config.c MCI_LPC23xx.c
  group Com Port
    ./: Serial.c Retarget.c
  group RT Agent
    ./: RTA_Config.c
  group Library
    ./: LCD.c
    C:/Keil4/ARM/Boards/Keil/MCB2300/RL/FlashFS/SD_File/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
target MCB2300 RT_Agent (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: SD_File
  c flags: Optim=4
  c define: RT_AGENT
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fd00000 size 0x2000
